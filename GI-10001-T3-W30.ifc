Properties of the parts of a building model (IFC2X3)

# File
Time: 2019-01-09T12:24:03
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: GI-10001-T3-W30
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT

# IfcFlowTerminal: Gino Bollards LED
In: Default Building
Type - Description: Wall mounted luminaires with upward and downward light distributions. Ideally suited to illuminate wall and surfaces, all possible to create light accents on vertical surfaces using LED lamp. The luminaire rated as CLASS I with integral driver. Colour temperature 2700K, 3000K and 4000K, LED CRI >80 and life time 50,000 Hours. Low copper content corrosion resistant die-cast aluminum frame and body. Stainless steel screws. Durable silicone rubber gasket and impact resistant toughened glass diffuser The luminaire is treated with a chemical chromatized protection before powder coating, ensuring high corrosion resistance. Lamp: 4 LED LED colour: 3000 K Power: 6 w. Weight: 5.0 kg. IP65 /EN 60598/CLASS I / CE /IK04; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: Gino, Bollard-Garden light-Pilar light; Housing color: All
General Information - Weight: 5 kg; Case length: 10.2 cm; Case width: 20.2 cm; Case height: 100 cm; Article name: Gino Bollards LED; Uld creation date: 01.09.2019 00:00:00
Photometric Information - Light output ratio: 0.999431; Luminous flux: 283.167 lm; Lamp names: GI-10001-T3-W30
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 5.6 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 5.6 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN
Pset_LampTypeCommon - ContributedLuminousFlux: 283.167 lm; LightEmitterNominalPower: 5.6 W; Spectrum: 380: 0.00369057, 385: 0.00441783, 390: 0.000103849, 395: 0.00241366, 400: 0.00163581, 405: 0.00497958, 410: 0.0120084, 415: 0.0190102, 420: 0.0434924, 425: 0.0923877, 430: 0.170081, 435: 0.269258, 440: 0.403809, 445: 0.530531, 450: 0.541211, 455: 0.426035, 460: 0.319709, 465: 0.266259, 470: 0.226744, 475: 0.207656, 480: 0.216726, 485: 0.242314, 490: 0.279103, 495: 0.328329, 500: 0.378364, 505: 0.420768, 510: 0.462021, 515: 0.499629, 520: 0.536003, 525: 0.569109, 530: 0.601715, 535: 0.639788, 540: 0.661954, 545: 0.700811, 550: 0.726342, 555: 0.76399, 560: 0.798739, 565: 0.823808, 570: 0.857425, 575: 0.88413, 580: 0.923658, 585: 0.9311, 590: 0.939471, 595: 0.955178, 600: 0.98714, 605: 0.994082, 610: 0.979624, 615: 0.966309, 620: 0.932084, 625: 0.905083, 630: 0.853313, 635: 0.812868, 640: 0.772045, 645: 0.723717, 650: 0.667977, 655: 0.605503, 660: 0.557213, 665: 0.512778, 670: 0.456803, 675: 0.410601, 680: 0.36937, 685: 0.329151, 690: 0.29255, 695: 0.261251, 700: 0.235075, 705: 0.201009, 710: 0.171701, 715: 0.153227, 720: 0.134668, 725: 0.105257, 730: 0.0969587, 735: 0.0843285, 740: 0.0757027, 745: 0.0619354, 750: 0.0559403, 755: 0.0477386, 760: 0.0404796, 765: 0.0367994, 770: 0.0297845, 775: 0.028116, 780: 0.0324477; ColorTemperature: 3114 K; ColorAppearance: 3114 K
